# Keil uVision project pro.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM;..\USER;..\HARDWARE\oled;..\HARDWARE\pressure;..\HARDWARE\PulseSensor;..\HARDWARE\temperature;..\HARDWARE\key;..\HARDWARE\esp8266;..\HARDWARE\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_exti.c
  group SYSTEM
    ../SYSTEM/: system_stm32f4xx.c system_stm32f4xx.h delay.c sys.c uart.c exti.c
  group USER
    ./: stm32f4xx_it.c main.c
  group HARDWARE
    ../HARDWARE/pressure/: MKS141.c
    ../HARDWARE/PulseSensor/: PulseSensor.c
    ../HARDWARE/temperature/: AS6221.c
    ../HARDWARE/arm/: arm.c
